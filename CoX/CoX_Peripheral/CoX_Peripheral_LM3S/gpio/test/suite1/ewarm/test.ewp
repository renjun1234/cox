# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libcox\; ..\..\..\..\testframe\; ..\src\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    ../../../../libcox/: xacmp.c xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xspi.c xsysctl.c xuart.c xwdt.c
  group startup
    ../../../../startup/src/: startup_ewarm.s
  group testcase
    ../src/: testcase.c xgpiotest2.c
  group testframe
    ../../../../testframe/: main.c test.c testport.c
